# Keil uVision project mpu6050_port.uvprojx, settings and files
target MPU6050 PORT (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mpu6050_port +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: HSE_VALUE=8000000, STM32F4XX, USE_STDPERIPH_DRIVER, USE_STM32F4_DISCOVERY
  c include: .\src;.\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\src;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Utilities\STM32F4-Discovery;.\Delay;.\I2C;.\MPU6050;.\Usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: main.c fputc_debug.c stm32f4xx_it.c
  group inc
    ./inc/: main.h stm32f4xx_conf.h stm32f4xx_it.h
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Utilities
    ./Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery.h
  group Delay
    ./Delay/: delay.c delay.h
  group I2C
    ./I2C/: myiic.c myiic.h
  group MPU6050
    ./MPU6050/: helper_3dmath.h MPU6050.c MPU6050.h MPU6050_6Axis_MotionApps20.c MPU6050_6Axis_MotionApps20.h
  group USART
    ./Usart/: usart.c usart.h
software components: Device:Startup 2.4.0
